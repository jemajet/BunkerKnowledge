# Keil uVision project CapSense_CSD_Design01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CapSense_CSD_Design01_PSoC3lib (library)
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h CapSense_CSD.c CapSense_CSD.h CapSense_CSD_CSHL.c CapSense_CSD_CSHL.h CapSense_CSD_INT.c CapSense_CSD_Pins.c CapSense_CSD_Pins.h CapSense_CSD_PM.c CapSense_CSD_SMS_Wrapper.c CapSense_CSD_TunerHelper.c CapSense_CSD_TunerHelper.h LCD_BarGraph.c LCD.c LCD.h LCD_PM.c LED1.c LED1.h LED1_aliases.h LED2.c LED2.h LED2_aliases.h CapSense_CSD_IntClock.c CapSense_CSD_IntClock.h CapSense_CSD_CompCH0.c CapSense_CSD_CompCH0.h CapSense_CSD_CompCH0_PM.c CapSense_CSD_AMuxCH0.c CapSense_CSD_AMuxCH0.h CapSense_CSD_IdacCH0.c CapSense_CSD_IdacCH0.h CapSense_CSD_IdacCH0_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cycodeshareimport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CapSense_CSD_Design01_PSoC3lib (library)
  c flags: Optimize=2
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
